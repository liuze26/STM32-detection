# Keil uVision project STM32空气监测仪.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32空气监测仪 +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\Delay;..\Fwlib\STM32F10x_StdPeriph_Driver\inc;..\Fwlib\STM32_USB-FS-Device_Driver\inc;..\USER;..\USMART;..\BSP;..\BSP\IIC;..\BSP\SPI;..\BSP\SYS;..\BSP\Timer;..\BSP\USART_1;..\BSP\USART_2;..\BSP\USART_3;..\APP\AM2320;..\APP\BH1750;..\APP\BMP280;..\APP\ESP8266;..\APP\KEY;..\APP\LED;..\APP\R8025AC;..\APP\USB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group BSP
    ../BSP/SPI/: SPI.c
    ../BSP/SYS/: SYS.c
    ../BSP/IIC/: IIC.c
    ../BSP/USART_1/: USART_1.c
    ../BSP/USART_2/: USART_2.c
    ../BSP/USART_3/: USART_3.c
    ../BSP/Timer/: Timer.c
    ../BSP/: BSP.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group Fwlib
    ../Fwlib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Fwlib/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USER
    ../USER/: main.c stm32f10x_it.c
  group Delay
    ../Delay/: Delay.c
  group APP
    ../APP/AM2320/: AM2320.c
    ../APP/BH1750/: BH1750.c
    ../APP/BMP280/: BMP280.c
    ../APP/ESP8266/: ESP8266.c
    ../APP/LED/: LED.c
    ../APP/USB/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
    ../APP/R8025AC/: R8025AC.c
    ../APP/KEY/: KEY.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
